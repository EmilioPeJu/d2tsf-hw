# Repository EmilioPeJu/d2tsf-hw

File README.md:

# Diamond II TimeStamp Feeder Hardware

This repository contains the PCB design for the board that obtains timestamps
from a GPS receiver (Ublox RCB-F9T) and pushes it to an EVG.

The output signals are: PPS, 1MHZ, SHIFT0 and SHITF1

## KiCad design d2tsf-hw.kicad_pcb

Notes on the sheet:
A (0) - Initial design
B - Fix wrong SWD wiring - Fix GPS receiver boot by adding a buffer (CC's contribution)
REVISIONS

Parts:
C5, C6, C7, C8, C9, C10, C14: 100n; C_0805_2012Metric
C11: 10n; C_0805_2012Metric
C12: 1u; C_0805_2012Metric
C13: 10u; C_1210_3225Metric
C15: 4.7u; C_1210_3225Metric
C16, C17: 22p; C_0805_2012Metric
J1: Reset MCU; PinHeader_1x02_P2.54mm_Vertical
U2: STM32F411RETx; LQFP-64_10x10mm_P0.5mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, U2.1 (VBAT), U2.13 (VDDA), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD); also elsewhere on the board
/Connectors/F9T_RX: U2.42 (PA9); also elsewhere on the board
/Connectors/F9T_TX: U2.43 (PA10); also elsewhere on the board
/Connectors/SWCLK: U2.49 (PA14); also elsewhere on the board
/Connectors/SWDIO: U2.46 (PA13); also elsewhere on the board
/Line Drivers/MCU_RX: U2.17 (PA3); also elsewhere on the board
/Line Drivers/MCU_TX: U2.16 (PA2); also elsewhere on the board
/Line Drivers/SHIFT0: U2.21 (PA5); also elsewhere on the board
/Line Drivers/SHIFT1: U2.22 (PA6); also elsewhere on the board
/MCU/OSC_IN: C16.1, U2.5 (PH0), Y1.1
/MCU/OSC_OUT: C17.1, U2.6 (PH1), Y1.3
B0: U2.26 (PB0); also elsewhere on the board
B1: U2.27 (PB1); also elsewhere on the board
B2: U2.28 (PB2); also elsewhere on the board
B3: U2.55 (PB3); also elsewhere on the board
B4: U2.56 (PB4); also elsewhere on the board
B5: U2.57 (PB5); also elsewhere on the board
B6: U2.58 (PB6); also elsewhere on the board
B7: U2.59 (PB7); also elsewhere on the board
GND: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.2, U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.60 (BOOT0), U2.63 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: C14.1, J1.1, U2.7 (NRST)
unnamed: C15.1, U2.30 (VCAP1)

Notes on the sheet:
Boot from flash

Parts:
C1, C2: 10u; C_1210_3225Metric
C31: 1u; C_1210_3225Metric
H1, H2: M3; MountingHole_3.2mm_M3
J2: Programming; PinHeader_1x04_P2.54mm_Vertical
J3: SHIFT0; EPL.00.250.NTN
J4: SHIFT1; EPL.00.250.NTN
J5: PSS; EPL.00.250.NTN
J6: 1MHZ; EPL.00.250.NTN
J7: Reset F9T; PinHeader_1x02_P2.54mm_Vertical
J8: ANT_VCC; PinHeader_1x02_P2.54mm_Vertical
J9: F9T Connector; F9T
J10: Serial; RJ45_Amphenol_54602-x08_Horizontal
J11: Barrel_Jack_Switch; BarrelJack_Horizontal
J12: Power; TerminalBlock_bornier-2_P5.08mm
J13: RX In; PinHeader_1x03_P2.54mm_Vertical
J14: GND; PinHeader_1x03_P2.54mm_Vertical
J15: TX Out; PinHeader_1x03_P2.54mm_Vertical
J16: Conn_01x09_Male; PinHeader_1x09_P2.54mm_Vertical
R4, R5: 10k; R_0805_2012Metric

Connections:
+3.3V: C2.1, J2.1, J9.2, R4.1, R5.1; also elsewhere on the board
+5V: J8.2, J11.1, J12.1; also elsewhere on the board
/Connectors/1MHZ: J9.7; also elsewhere on the board
/Connectors/1MHZ_TTL: J6.1; also elsewhere on the board
/Connectors/F9T_RX: J9.5; also elsewhere on the board
/Connectors/F9T_TX: J9.3; also elsewhere on the board
/Connectors/MCU_RS232_RX: J13.2; also elsewhere on the board
/Connectors/MCU_RS232_TX: J15.2; also elsewhere on the board
/Connectors/PPS: J9.6; also elsewhere on the board
/Connectors/PPS_TTL: J5.1; also elsewhere on the board
/Connectors/SHIFT0_TTL: J3.1; also elsewhere on the board
/Connectors/SHIFT1_TTL: J4.1; also elsewhere on the board
/Connectors/SWCLK: J2.3, R5.2; also elsewhere on the board
/Connectors/SWDIO: J2.2, R4.2; also elsewhere on the board
/Connectors/VCC_ANT: C1.1, C31.1, J8.1, J9.1
B0: J16.1; also elsewhere on the board
B1: J16.2; also elsewhere on the board
B2: J16.3; also elsewhere on the board
B3: J16.4; also elsewhere on the board
B4: J16.5; also elsewhere on the board
B5: J16.6; also elsewhere on the board
B6: J16.7; also elsewhere on the board
B7: J16.8; also elsewhere on the board
GND: C1.2, C2.2, C31.2, J2.4, J3.2, J3.3, J3.4, J3.5, J4.2, J4.3, J4.4, J4.5, J5.2, J5.3, J5.4, J5.5, J6.2, J6.3, J6.4, J6.5, J7.1, J9.8, J11.2, J11.3, J12.2, J14.2, J16.9; also elsewhere on the board
unnamed: J7.2, J9.4
unnamed: J10.3, J13.1, J14.3
unnamed: J10.4, J13.3, J14.1
unnamed: J10.6, J15.1
unnamed: J10.5, J15.3

Notes on the sheet:
Debugging and Programming
LEMO connectors
Power Connector
RS232 Connector
RCB-F9T Connector
Mounting Holes

Parts:
C18, C19, C21, C22: 100n; C_0805_2012Metric
C20, C23: 10u; C_1210_3225Metric
C24, C25, C26, C27, C28: 0.1u; C_0805_2012Metric
R2, R3: 10k; R_0805_2012Metric
TP1: SHIFT0; TestPoint_Pad_D1.0mm
TP2: SHIFT1; TestPoint_Pad_D1.0mm
TP3: PPS; TestPoint_Pad_D1.0mm
TP4: 1MHZ; TestPoint_Pad_D1.0mm
U3, U4: SN74LVC8T245PWR; TSSOP-24_4.4x7.8mm_P0.65mm
U5: MAX3232; SOIC-16_3.9x9.9mm_P1.27mm
U6, U7: 74LVC1G125; SOT-23-5_HandSoldering

Connections:
+3.3V: C18.1, C21.1, C24.1, R2.1, R3.1, U3.1 (VCCA), U4.1 (VCCA), U5.16 (VCC), U6.5 (VCC), U7.5 (VCC); also elsewhere on the board
+5V: C19.1, C20.1, C22.1, C23.1, U3.23 (VCCB), U3.24 (VCCB), U4.23 (VCCB), U4.24 (VCCB); also elsewhere on the board
/Connectors/1MHZ: U7.2; also elsewhere on the board
/Connectors/1MHZ_TTL: U4.14 (B8), U4.15 (B7), U4.16 (B6), U4.17 (B5); also elsewhere on the board
/Connectors/MCU_RS232_RX: U5.13 (R1IN); also elsewhere on the board
/Connectors/MCU_RS232_TX: U5.14 (T1OUT); also elsewhere on the board
/Connectors/PPS: U6.2; also elsewhere on the board
/Connectors/PPS_TTL: U4.18 (B4), U4.19 (B3), U4.20 (B2), U4.21 (B1); also elsewhere on the board
/Connectors/SHIFT0_TTL: U3.18 (B4), U3.19 (B3), U3.20 (B2), U3.21 (B1); also elsewhere on the board
/Connectors/SHIFT1_TTL: U3.14 (B8), U3.15 (B7), U3.16 (B6), U3.17 (B5); also elsewhere on the board
/Line Drivers/MCU_RX: U5.12 (R1OUT); also elsewhere on the board
/Line Drivers/MCU_TX: U5.11 (T1IN); also elsewhere on the board
/Line Drivers/SHIFT0: TP1.1, U3.3 (A1), U3.4 (A2), U3.5 (A3), U3.6 (A4); also elsewhere on the board
/Line Drivers/SHIFT1: TP2.1, U3.7 (A5), U3.8 (A6), U3.9 (A7), U3.10 (A8); also elsewhere on the board
GND: C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C27.2, C28.2, U3.11 (GND), U3.12 (GND), U3.13 (GND), U3.22 (~OE), U4.11 (GND), U4.12 (GND), U4.13 (GND), U4.22 (~OE), U5.10 (T2IN), U5.15 (GND), U6.1, U6.3 (GND), U7.1, U7.3 (GND); also elsewhere on the board
unnamed: R2.2, U3.2 (DIR)
unnamed: TP3.1, U4.3 (A1), U4.4 (A2), U4.5 (A3), U4.6 (A4), U6.4
unnamed: TP4.1, U4.7 (A5), U4.8 (A6), U4.9 (A7), U4.10 (A8), U7.4
unnamed: R3.2, U4.2 (DIR)
unnamed: C25.1, U5.1 (C1+)
unnamed: C25.2, U5.3 (C1-)
unnamed: C26.1, U5.4 (C2+)
unnamed: C26.2, U5.5 (C2-)
unnamed: C28.1, U5.2 (VS+)
unnamed: C27.1, U5.6 (VS-)

Parts:
C3, C4: 22u; C_1210_3225Metric
C29, C30: 10u; C_1210_3225Metric
D1: LED; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
R1: 560; R_0805_2012Metric
U1: AMS1117; SOT-223-3_TabPin2

Connections:
+3.3V: C4.1, C30.1, D1.2 (A), U1.2 (VO); also elsewhere on the board
+5V: C3.1, C29.1, U1.3 (VI); also elsewhere on the board
GND: C3.2, C4.2, C29.2, C30.2, R1.2, U1.1 (ADJ); also elsewhere on the board
unnamed: D1.1 (K), R1.1

Notes on the sheet:
Max consumptions: - STM32 microcontroller 100mA at 3.3V - GPS antenna 100mA at 5V - GPS receiver 100mA at 3.3V - Level shifter 1 300mA at 5V - Level shifter 2 300mA at 5V Max Power Consumption ~4W

Board: 4 copper layers, 160.2 x 69.8 mm, 68 parts (0 on the bottom side), 48 nets.

Other parts of the board:
LOGO1: diamond-logo

File d2tsf-hw-bom.csv:

Comment,Designator,Footprint,LCSC Part #,Link
10u cap,"C1,C2,C13,C20,C23,C29,C30",C_1210_3225Metric,,
22u cap,"C3,C4",C_1210_3225Metric,,
100n cap,"C5,C6,C7,C8,C9,C10,C14,C18,C19,C21,C22",C_0805_2012Metric,,
10n cap,C11,C_0805_2012Metric,,
1u cap,C12,C_0805_2012Metric,,
4.7u cap,C15,C_1210_3225Metric,,
22p cap,"C16,C17",C_0805_2012Metric,,
0.1u cap,"C24,C25,C26,C27,C28",C_0805_2012Metric,,
1u cap,C31,C_1210_3225Metric,,
LED Light emitting diode,D1,LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm,,
"33uH Ferrite bead, small symbol",FB1,C_0805_2012Metric,,
M3 Mounting Hole without connection,"H1,H2",MountingHole_3.2mm_M3,,
"Reset MCU Generic connector, single row, 01x02",J1,PinHeader_1x02_P2.54mm_Vertical,,
"Programming Generic connector, single row, 01x04",J2,PinHeader_1x04_P2.54mm_Vertical,,
SHIFT0 5-pin LEMO connector,J3,EPL.00.250.NTN,,
SHIFT1 5-pin LEMO connector,J4,EPL.00.250.NTN,,
PSS 5-pin LEMO connector,J5,EPL.00.250.NTN,,
1MHZ 5-pin LEMO connector,J6,EPL.00.250.NTN,,
"Reset F9T Generic connector, single row, 01x02",J7,PinHeader_1x02_P2.54mm_Vertical,,
"ANT_VCC Generic connector, single row, 01x02",J8,PinHeader_1x02_P2.54mm_Vertical,,
"F9T Connector Generic connector, double row, 02x04, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers)",J9,F9T,,
"Serial RJ connector, 8P8C (8 positions 8 connected)",J10,RJ45_Amphenol_54602-x08_Horizontal,,
Barrel_Jack_Switch DC Barrel Jack with an internal switch,J11,BarrelJack_Horizontal,,
"Power Generic screw terminal, single row, 01x02",J12,TerminalBlock_bornier-2_P5.08mm,,
"RX In Generic connector, single row, 01x03",J13,PinHeader_1x03_P2.54mm_Vertical,,
"GND Generic connector, single row, 01x03",J14,PinHeader_1x03_P2.54mm_Vertical,,
"TX Out Generic connector, single row, 01x03",J15,PinHeader_1x03_P2.54mm_Vertical,,
"Conn_01x09_Male Generic connector, single row, 01x09",J16,PinHeader_1x09_P2.54mm_Vertical,,
560 Resistor,R1,R_0805_2012Metric,,
10k Resistor,"R2,R3",R_0805_2012Metric,,
SHIFT0 test point,TP1,TestPoint_Pad_D1.0mm,,
SHIFT1 test point,TP2,TestPoint_Pad_D1.0mm,,
PPS test point,TP3,TestPoint_Pad_D1.0mm,,
1MHZ test point,TP4,TestPoint_Pad_D1.0mm,,
"AMS1117 1A Low Dropout regulator, positive, adjustable output, SOT-223",U1,SOT-223-3_TabPin2,,
"STM32F411RETx ARM Cortex-M4 MCU, 512KB flash, 128KB RAM, 100MHz, 1.7-3.6V, 50 GPIO, LQFP-64",U2,LQFP-64_10x10mm_P0.5mm,C94355,https://jlcpcb.com/partdetail/Stmicroelectronics-STM32F411RE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
SN74LVC8T245PWR ,"U3,U4",SOP65P640X120-24N,C27643,https://jlcpcb.com/partdetail/TexasInstruments-SN74LVC8T245P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
"MAX3232 3.0V to 5.5V, Low-Power, up to 1Mbps, True RS-232 Transceivers Using Four 0.1μF External Capacitors",U5,SOIC127P600X175-16N,C2904738,https://jlcpcb.com/partdetail/3170777-MAX3232ESE/C2904738
"16MHz Four pin crystal, GND on pins 2 and 4",Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,,

## Commit log

2022-11-08 Change to use 4 layers
    - In1 is GND layer
    - In2 is 3.3V layer
    - Additionally, a few test points were added
2022-11-08 Increase clearance from mounting hole
2022-11-21 Add initial BOM and gerber files
2022-11-21 Update schematic plot
2022-11-21 Move pin 1 indicator closer to pin
2022-11-24 Annotate connectors
2022-11-24 Fix inverse numbering of programming header
2022-11-28 Fix wrong connection of SWD pins
2022-12-02 Release board rev1
    Ferrite bead 1 was removed (not needed)
2022-12-09 Add pull up resistors to SWD signals
2022-12-10 Add initial readme
2023-01-05 Mark microcontroller pin 1 on silkscreen
2023-01-06 Add known issues in README
2023-01-12 Add TODO in README
2023-02-16 Convert to KiCad 7 format
2023-02-22 Rev3: Fix GPS receiver start problem and update to KiCad 7
    - Pin TP2 of GPS receiver seems to be pulled down briefly at start time,
    this triggers the safe boot mode. A buffer was added to address this
    issue. Thanks Chris C. for the fix and thanks Paul H. for the
    investigation
    - All files were adapted to KiCad 7 format and many symbols and footprints
    were replaced with newer ones.
2023-03-20 Add metadata to follow Diamond's standard and use a letter for the revision
